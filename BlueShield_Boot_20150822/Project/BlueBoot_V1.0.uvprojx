# Keil uVision project BlueBoot_V1.0.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F411CEYx STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BlueBoot_V1.0
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F411xE,USE_HSE_BYPASS
  c include: ..\Libirary\FATFS;..\Libirary\STM32_FWLIB\inc;..\Libirary\STM32_USBLIB\inc;..\Sourcecode\inc;..\Sourcecode\BSP\inc;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.2.0\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ../Sourcecode/: main.c stm32f4xx_it.c system_stm32f4xx.c
    ../Sourcecode/BSP/src/: bsp_Delay.c bsp_FileSystem.c bsp_Gpio.c bsp_Sdio.c command.c flash_if.c bsp_Adc.c
    ../Libirary/: startup_stm32f411xe.s
  group Library
    ../Libirary/STM32_FWLIB/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_flash.c stm32f4xx_pwr.c stm32f4xx_adc.c
    ../Libirary/FATFS/: diskio.c ff.c unicode.c
