# Keil uVision project AKEY_Blue.uvprojx, settings and files
target AKEY_Blue (ARM-ADS)
  device: STM32F411CEYx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(100000000) ELITTLE
  output: AKEY_Blue +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./bin/Akey.bin ./Output/Akey_Blue.axf
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F411xE,USE_HSE_BYPASS
  c include: ..\Libirary\FATFS;..\Libirary\FreeRTOS;..\Libirary\STM32_CryptoLIB;..\Libirary\STM32_FWLIB\inc;..\Libirary\STM32_USBLIB\inc;..\Sourcecode\inc;..\Sourcecode\BSP\inc;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.2.0\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8040000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ../Sourcecode/: main.c stm32f4xx_it.c Task_Communicate_protocol.c system_stm32f4xx.c Task_HardwareControl.c
  group BSP
    ../Sourcecode/BSP/src/: bsp_Adc.c bsp_AesEcb256.c bsp_Delay.c bsp_FileSystem.c bsp_Sdio.c bsp_Usart.c bsp_Gpio.c bsp_RTC.c
    ../Libirary/STM32_CryptoLIB/: M4_CryptoFW_RngHW_2_0_6.lib
    ../Libirary/: startup_stm32f411xe.s
  group FreeRTOS
    ../Libirary/FreeRTOS/: heap_2.c list.c port.c queue.c tasks.c
  group USB
    ../Libirary/STM32_USBLIB/src/: usb_bsp.c usb_core.c usb_dcd.c usb_dcd_int.c usbd_core.c usbd_desc.c usbd_ioreq.c usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c usbd_req.c usbd_storage.c usbd_usr.c
  group FATFS
    ../Libirary/FATFS/: diskio.c ff.c unicode.c
  group FWLIB
    ../Libirary/STM32_FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
